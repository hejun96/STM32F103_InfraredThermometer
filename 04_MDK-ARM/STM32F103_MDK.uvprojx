# Keil uVision project STM32F103_MDK.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_MDK
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\00_CMSIS\C_inc;..\01_FWLIB\inc;..\02_USER\USER_INC;..\03_SYSTEM\03_SYSTEM_INC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group 00_STARTUP
    ../00_CMSIS/C_startup/: startup_stm32f10x_hd.s
  group 01_CMSIS
    ../00_CMSIS/C_src/: core_cm3.c system_stm32f10x.c
  group 02_FWLIB
    ../01_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group 03_USER
    ../02_USER/USER_SRC/: BspAdc.c BspAT24CXX.c BspIIC.c GPIO.c stm32f10x_it.c BspButton.c BspLed.c BspUsart.c BspBuzzer.c BspTimer.c
    ../02_USER/: main.c
  group 04_SYSTEM
    ../03_SYSTEM/03_SYSTEM_SRC/: delay.c sys.c
